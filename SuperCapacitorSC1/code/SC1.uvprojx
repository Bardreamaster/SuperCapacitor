# Keil uVision project SC1.uvprojx, settings and files
target USER (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SC1 +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\USER;.\USER\Main;.\USER\Hardware\adc;.\USER\Hardware\delay;.\USER\Hardware\led;.\USER\Hardware\sys;.\USER\Hardware\timer;.\USER\Hardware\usart;.\USER\Hardware\switch;.\USER\Hardware\powerlimit
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./USER/Main/: main.h main.c
  group Hardware
    ./USER/Hardware/adc/: adc.c
    ./USER/Hardware/delay/: delay.c
    ./USER/Hardware/led/: led.c
    ./USER/Hardware/timer/: timer.c
    ./USER/Hardware/usart/: usart.c
    ./USER/Hardware/switch/: switch.c
    ./USER/Hardware/powerlimit/: powerlimit.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
