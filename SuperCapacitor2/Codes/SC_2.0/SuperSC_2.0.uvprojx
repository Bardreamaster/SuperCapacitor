# Keil uVision project SuperSC_2.0.uvprojx, settings and files
target SC2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SuperSC_2.0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\RTE\_SC2\Main;.\RTE\_SC2\Hardware;.\RTE\_SC2\Hardware\adc;.\RTE\_SC2\Hardware\delay;.\RTE\_SC2\Hardware\gpio;.\RTE\_SC2\Hardware\led;.\RTE\_SC2\Hardware\powerlimit;.\RTE\_SC2\Hardware\switch;.\RTE\_SC2\Hardware\sys;.\RTE\_SC2\Hardware\timer;.\RTE\_SC2\Hardware\usart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main
    ./RTE/_SC2/Main/: main.c main.h
  group Hardware
    ./RTE/_SC2/Hardware/adc/: adc.c adc.h
    ./RTE/_SC2/Hardware/delay/: delay.c delay.h
    ./RTE/_SC2/Hardware/led/: led.c led.h
    ./RTE/_SC2/Hardware/powerlimit/: powerlimit.c powerlimit.h
    ./RTE/_SC2/Hardware/timer/: timer.c timer.h
    ./RTE/_SC2/Hardware/usart/: usart.c usart.h
    ./RTE/_SC2/Hardware/gpio/: gpio.c gpio.h
software components: CMSIS:CORE 5.3.0, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
